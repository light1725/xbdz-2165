# Keil uVision project 2165.uvproj, settings and files
target 2165 (MCS-51)
  device: SC92F8463B SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF)  XRAM(0-0xFF) CLOCK(16000000)
  output: 2165 +hex
  c flags: Optimize=8
  c define: SC92F846xB
  c include: ..\FWLib\SC92F_Lib\inc;..\User
  link misc: REMOVEUNUSED
  group User
    ../User/: main.c SC_Init.c SC_it.c SysFunVarDefine.c CompCtrlDefine.c CallBackFunction.c HostControl.c BSP.c Key.c Display.c TKDriver.c SC92F8X6XB_HighSensitive_lib_T1_L_V2.2.0.LIB
  group FWLib
    ../FWLib/SC92F_Lib/src/: sc92f_gpio.c sc92f_option.c
  group Startup
    ./: STARTUP.A51
